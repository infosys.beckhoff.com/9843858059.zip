PROGRAM MAIN
VAR
END_VAR

Tc2_DALI_Test();
Tc3_DALI_Test();

END_PROGRAM
